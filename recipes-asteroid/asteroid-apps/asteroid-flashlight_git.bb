SUMMARY = "Asteroid's flashlight app"
HOMEPAGE = "https://github.com/AsteroidOS/asteroid-flashlight.git"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d"

SRC_URI = "git://github.com/AsteroidOS/asteroid-flashlight.git;protocol=https;branch=master"
SRCREV = "dd9dc0b09bf2a15ab91cff5d2d2865a2f8a324d2"
PV = "2.1+29+git"

require asteroid-app.inc
