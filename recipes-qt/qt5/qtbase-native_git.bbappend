PACKAGECONFIG_append = " gui "
#PACKAGECONFIG_CONFARGS_append = " -make tools -make libs "
PACKAGECONFIG_CONFARGS_append = " -make tools "